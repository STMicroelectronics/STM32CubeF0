# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F072B-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/BSP/STM32F072B-Discovery
    ../../../../../../Drivers/BSP/STM32F072B-Discovery/: stm32f072b_discovery.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_tsc.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Example/User
    ../Src/: stm32f0xx_it.c stmCriticalSection.c stm32f0xx_hal_msp.c main.c tsl_user.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_object.c tsl.c tsl_dxs.c tsl_filter.c tsl_linrot.c tsl_ecs.c tsl_globals.c tsl_time.c tsl_acq_tsc.c tsl_acq.c tsl_touchkey.c
software components: CMSIS:CORE 4.3.0
