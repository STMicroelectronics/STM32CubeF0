# Keil uVision project Project.uvprojx, settings and files
target STM32F030R8-Nucleo (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030R8-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx-Nucleo
  library: MicroLIB
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Example/User
    ../Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c
software components: CMSIS:CORE 4.3.0
