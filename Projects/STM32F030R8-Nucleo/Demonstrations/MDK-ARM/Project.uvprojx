# Keil uVision project Project.uvprojx, settings and files
target STM32F030R8-Nucleo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030R8-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO,SD_GET_STATUS_WORKAROUND
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo;..\..\..\..\Drivers\BSP\Adafruit_Shield;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: fatfs_storage.c stm32f0xx_it.c main.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_dma.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
software components: CMSIS:CORE 4.1.0
