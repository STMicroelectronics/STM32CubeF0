# Keil uVision project Project.uvprojx, settings and files
target STM32F0308-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0308-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM320308_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0308-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F0308-Discovery
    ../../../../../../Drivers/BSP/STM32F0308-Discovery/: stm32f0308_discovery.c
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Example/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c
software components: CMSIS:CORE 4.3.0
