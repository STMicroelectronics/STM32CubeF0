# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072RB-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx-Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Example/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
