# Keil uVision project Project.uvprojx, settings and files
target STM32091C_EVAL (ARM-ADS)
  device: STM32F091VC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32091C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F091xC,USE_HAL_DRIVER,USE_STM32091C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32091C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f091xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/BSP/STM32091C_EVAL
    ../../../../../../Drivers/BSP/STM32091C_EVAL/: stm32091c_eval.c
  group Example/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c
software components: CMSIS:CORE 4.1.0
