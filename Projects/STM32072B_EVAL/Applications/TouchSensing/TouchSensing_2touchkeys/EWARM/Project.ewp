# IAR project Project.ewp, settings and files
configuration STM32072B_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F072xB; USE_HAL_DRIVER; USE_STM32072B_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32072B_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_TouchSensing_Library\inc; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32072B_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: stm32f0xx_it.c stmCriticalSection.c tsl_user.c main.c stm32f0xx_hal_msp.c
  group Application/EWARM
    ./: startup_stm32f072xb.s
  group Drivers/BSP/STM32072B_EVAL
    ../../../../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq.c tsl_acq_tsc.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_touchkey.c
