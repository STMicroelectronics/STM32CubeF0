# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL_USB (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32072B_EVAL_USB
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_STM32072B_EVAL,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32072B_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Middlewares/STM32_USBD_Library/Class/Custom_HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_adc.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c
  group Application/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c usbd_customhid_if.c usbd_conf.c usbd_desc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c
software components: CMSIS:CORE 4.3.0
