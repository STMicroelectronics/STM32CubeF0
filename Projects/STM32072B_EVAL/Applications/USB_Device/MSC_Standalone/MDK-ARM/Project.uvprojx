# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL_USB (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32072B_EVAL_USB
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_STM32072B_EVAL,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32072B_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_data.c usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c
  group Application/User
    ../Src/: stm32f0xx_it.c main.c usbd_conf.c usbd_desc.c usbd_storage.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval_sd.c stm32072b_eval.c
software components: CMSIS:CORE 4.3.0
