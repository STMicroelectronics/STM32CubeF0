# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32072B_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32072B_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32072B_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c list.c queue.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: stm32f0xx_it.c main.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
