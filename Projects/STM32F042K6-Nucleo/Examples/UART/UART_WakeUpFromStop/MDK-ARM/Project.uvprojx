# Keil uVision project Project.uvprojx, settings and files
target STM32F042K6_NUCLEO (ARM-ADS)
  device: STM32F042K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F042K6_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F042x6,USE_STM32F0XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx_Nucleo_32
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F0xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32F0xx_Nucleo_32/: stm32f0xx_nucleo_32.c
  group Example/MDK-ARM
    ./: startup_stm32f042x6.s
  group Example/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_hal.c
software components: CMSIS:CORE 4.3.0
